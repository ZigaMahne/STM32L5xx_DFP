# Keil uVision project STM32L562_OSPI_MX25L51245G.uvprojx, settings and files
target STM32L562E_DK _MX25LM51245G (6140000::V6.14::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.1-dev1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: STM32L562E_DK_MX25L51245G
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: STM32L562E_DK MX25LM51245G
  c include: .\Drivers\STM32L5xx_HAL_Driver\Inc;.\Drivers\BSP\STM32L562E-DK;.\Drivers\BSP\Components\mx25lm51245g
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Flash Programming
    ./: FlashDev.c FlashPrg.c
  group Device
    ./: stm32l5xx_helper.c
  group Driver HAL
    ./Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal.c stm32l5xx_hal_cortex.c stm32l5xx_hal_dma.c stm32l5xx_hal_gpio.c stm32l5xx_hal_ospi.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c
  group Driver BSP
    ./Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ./Drivers/BSP/STM32L562E-DK/: stm32l562e_discovery_ospi.c
    ./Drivers/BSP/STM32L552E-EV/: stm32l552e_eval_ospi.c
    ./Drivers/BSP/Components/iss66wvh8m8/: iss66wvh8m8.c
target STM32L552E_EVAL_MX25LM51245G (6140000::V6.14::ARMCLANG)
  device: STM32L562QEIxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.2.1-dev1
  cpu: as above
  output: STM32L552E_EVAL_MX25L51245G
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: STM32L552E_EVAL MX25LM51245G
  c include: .\Drivers\STM32L5xx_HAL_Driver\Inc;.\Drivers\BSP\STM32L552E-EV;.\Drivers\BSP\Components\mx25lm51245g;.\Drivers\BSP\Components\iss66wvh8m8
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x30000000 size 0x40000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.4.0
